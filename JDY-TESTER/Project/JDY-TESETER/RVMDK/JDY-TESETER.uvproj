# Keil uVision project JDY-TESETER.uvproj, settings and files
target BAT5K-HOST (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: JDY-Test +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin --output=.\obj\output\JDY-Test.bin .\obj\JDY-Test.axf
  c flags: Optim=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\;..\..\inc;..\..\BSP;..\..\src;..\..\uC-CPU;..\..\uC-CPU\ARM-Cortex-M3\Keil;..\..\uC-LIB;..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\Keil;..\..\uCOS-II\Source;..\..\..\Libraries\CMSIS\Core\CM3;..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\..\Utilities\STM32_EVAL;..\..\src;..\include\arch;..\src;..\..\queue;..\app;..\..\LwIP\api;..\..\LwIP\arch;..\..\LwIP\arch\API;..\..\LwIP\core;..\..\LwIP\core\ipv4;..\..\LwIP\include;..\..\LwIP\include\arch;D:\soft_install\keil\ARM\ARMCC\include;..\..\USR;..\..\USB\FATFS_V0.08A\src;..\..\USB\STM32_USB_HOST_Driver\inc;..\..\USB\STM32_USB_HOST_Library\Core\inc;..\..\USB\STM32_USB_HOST_Library\Class\MSC\inc;..\..\USB\MSC;..\..\USB\STM32_USB_HOST_Library\Class\HID\inc;..\app;..\..\STDriver;..\..\STDriver\adc;..\..\STDriver\can;..\..\STDriver\crc;..\..\STDriver\gpio;..\..\STDriver\i2c;..\..\STDriver\rtc;..\..\STDriver\uart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartupCode
    ../../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group Stdperiph_driver
    ../src/: stm32f10x_it.c
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_sdio.c stm32f10x_fsmc.c stm32f10x_dma.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_exti.c stm32f10x_flash.c
  group BSP
    ../../BSP/: bsp.c Init.c Message.c SysCtrl.c MbsSlave.c
  group App
    ../app/: appstart.c appLCD.c AppJdyTest.c AppUpdate.c LcdComm.c
  group uC/CPU
    ../../uC-CPU/ARM-Cortex-M3/Keil/: cpu_a.asm cpu_c.c
  group uC/LIB
    ../../uC-LIB/: lib_str.c lib_mem.c
    ../../uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group uC/OS-II
    ../../uCOS-II/Source/: os_time.c os_tmr.c os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c
  group uCOS/port
    ../../uCOS-II/Ports/ARM-Cortex-M3/Generic/Keil/: os_dbg.c os_cpu_a.asm os_cpu_c.c
  group queue
    ../../queue/: queue.c
  group STDriver
    ../../STDriver/adc/: ADC.c
    ../../STDriver/crc/: crc.c
    ../../STDriver/gpio/: gpio.c
    ../../STDriver/i2c/: i2c.c
    ../../STDriver/rtc/: rtc.c
    ../../STDriver/uart/: uart.c
